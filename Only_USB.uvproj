# Keil uVision project Only_USB.uvproj, settings and files
target Only_USB_Prj (ARM-ADS)
  device: STM32F103CB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Only_USB +hex
  c flags: Optim=4
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD, USE_USB_OTG_FS
  c misc: --c99
  c include: .\CMSIS;.\Main;.\STM32F10x_StdPeriph_Driver\inc;.\STM32_USB-FS-Device_Driver\inc;.\STM3210B_EVAL;.\fat_sd
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CMSIS
    ./CMSIS/: core_cm3.c system_stm32f10x.c
  group Main
    ./Main/: main.c stm32f10x_it.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c hw_config.c startup_stm32f10x_md.s
  group StdPeriph
    ./STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
  group USB_Driver
    ./STM32_USB-FS-Device_Driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group SD
    ./fat_sd/: sd_spi_stm32.c fattime.c ff.c
    ./fat_sd/option/: ccsbcs.c
